Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Numéro du projet
Time: 2021-12-21T23:12:20
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190510_1515(x64) - Exporter 18.4.0.0 - Interface alternative d'export 18.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Dec 21 23:12:20 2021 * Host: SWIFT * Database: C:\Users\MFBIM~1\AppData\Local\Temp\{204CC95D-2F85-4A02-973C-92D678EBBE55}\ifc * Database version: 5507 * Database creation date: Tue Dec 21 23:12:18 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Dec 21 23:12:19 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Dec 21 23:12:19 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Numéro du projet
LongName: Nom du projet; Phase: Etat du projet

# IfcSite, Default
RefLatitude: 42, 12, 46, 804504; RefLongitude: -71, -2, 0, -602416; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey: Niveau:Pointe 8 mm, Niveau 1
LongName: Niveau 1; Elevation: 0 mm

# IfcBuildingElementProxy: Logo, TARKETT Sports - Logo:Logo:475882
In: Niveau 1
Type - Material: TARKETT - Logo - Bleu
Type - Pset_BuildingElementProxyCommon - Reference: Logo
Type - Pset_QuantityTakeOff - Reference: Logo
Pset_BuildingElementProxyCommon - sets with these values: 2

# IfcBuildingElementProxy: Texte 3D:600mm Arial, Texte 3D:600mm Arial:370015
In: Niveau 1
Pset_BuildingElementProxyCommon - Reference: 600mm Arial; sets with these values: 2

# IfcBuildingElementProxy: Texte 3D:80mm Arial (24)
In: Niveau 1
Pset_BuildingElementProxyCommon - Reference: 80mm Arial; sets with these values: 2
Name (Texte 3D:80mm Arial:...)
473043
473044
473045
473046
473047
473048
473049
473050
473051
473052
473053
473054
473055
473056
473057
473058
473059
473060
473061
473062
473063
473064
473065
473066

# IfcCovering: Sol:TARKETT - Omnisports Active+ - Beech, Sol:TARKETT - Omnisports Active+ - Beech:373705
In: Niveau 1
Type - PredefinedType: FLOORING; Material: TARKETT - Omnisports Active+ - Beech 8.1 mm
Type - Pset_ConcreteElementGeneral - FireRating: Cfl - s1
Type - Pset_CoveringCommon - Reference: TARKETT - Omnisports Active+ - Beech; FireRating: Cfl - s1
Type - Pset_ManufacturerTypeInformation - Manufacturer: TARKETT
Type - Pset_QuantityTakeOff - Reference: TARKETT - Omnisports Active+ - Beech
Type - PSet_Tarkett_EN - Underfloor heating: yes; Tensile strength: 0; Type of floorcovering: Heterogeneous indoor sports floorcoverings; Flammability: Cfl - s1; Thermal resistance: 0.12 kg/K/s3; Design: Beech; Dimension: 2m x 20.5lm; Plasticizer: Phthalate-free; Reaction to fire: Cfl - s1; Reduction of in-room impact noise: Class A (≤65dB); Residual indentation: ≤ 0.50 mm; Total mass: 4.76; Total thickness: 8.1 mm; Total VOC emissions (after 28 days): ≤ 10 μg/m³; URL: https://www.tarkettsportsindoor.com/; Acoustic performance: 21 dB; Board dimensions: -; Elongation at break: -; Friction: 80 to 110; Resistance to a rolling load: ≤ 0.50 mm; Resistance to wear: ≤ 0.25g; Shock absorption: P2 (≥35%); Specular gloss: ≤ 30; Temperature range: -; Vertical ball behaviour: ≥ 95%; Vertical deformation: P2
Classification: C3020400 Flooring (Uniformat)
Pset_CoveringCommon - TotalThickness: 8.1 mm

# IfcCovering: Sol:TARKETT - Omnisports Active+ - Black, Sol:TARKETT - Omnisports Active+ - Black:373777
In: Niveau 1
Type - PredefinedType: FLOORING; Material: TARKETT - Omnisports Active+ - Uni BLACK 8.1 mm
Type - Pset_ConcreteElementGeneral - FireRating: Cfl - s1
Type - Pset_CoveringCommon - Reference: TARKETT - Omnisports Active+ - Black; FireRating: Cfl - s1
Type - Pset_ManufacturerTypeInformation - Manufacturer: TARKETT
Type - Pset_QuantityTakeOff - Reference: TARKETT - Omnisports Active+ - Black
Type - PSet_Tarkett_EN - Underfloor heating: yes; Tensile strength: 0; Type of floorcovering: Heterogeneous indoor sports floorcoverings; Flammability: Cfl - s1; Thermal resistance: 0.12 kg/K/s3; Design: Black; Dimension: 2m x 20.5lm; Plasticizer: Phthalate-free; Reaction to fire: Cfl - s1; Reduction of in-room impact noise: Class A (≤65dB); Residual indentation: ≤ 0.50 mm; Total mass: 4.76; Total thickness: 8.1 mm; Total VOC emissions (after 28 days): ≤ 10 μg/m³; URL: https://www.tarkettsportsindoor.com/; Acoustic performance: 21 dB; Board dimensions: -; Elongation at break: -; Friction: 80 to 110; Resistance to a rolling load: ≤ 0.50 mm; Resistance to wear: ≤ 0.25g; Shock absorption: P2 (≥35%); Specular gloss: ≤ 30; Temperature range: -; Vertical ball behaviour: ≥ 95%; Vertical deformation: P2
Classification: C3020400 Flooring (Uniformat)
Pset_CoveringCommon - TotalThickness: 8.1 mm

# IfcCovering: Sol:TARKETT - Omnisports Active+ - Classic Oak, Sol:TARKETT - Omnisports Active+ - Classic Oak:373714
In: Niveau 1
Type - PredefinedType: FLOORING; Material: TARKETT - Omnisports Active+ - Classic Oak 8.1 mm
Type - Pset_ConcreteElementGeneral - FireRating: Cfl - s1
Type - Pset_CoveringCommon - Reference: TARKETT - Omnisports Active+ - Classic Oak; FireRating: Cfl - s1
Type - Pset_ManufacturerTypeInformation - Manufacturer: TARKETT
Type - Pset_QuantityTakeOff - Reference: TARKETT - Omnisports Active+ - Classic Oak
Type - PSet_Tarkett_EN - Underfloor heating: yes; Tensile strength: 0; Type of floorcovering: Heterogeneous indoor sports floorcoverings; Flammability: Cfl - s1; Thermal resistance: 0.12 kg/K/s3; Design: Classic Oak; Dimension: 2m x 20.5lm; Plasticizer: Phthalate-free; Reaction to fire: Cfl - s1; Reduction of in-room impact noise: Class A (≤65dB); Residual indentation: ≤ 0.50 mm; Total mass: 4.76; Total thickness: 8.1 mm; Total VOC emissions (after 28 days): ≤ 10 μg/m³; URL: https://www.tarkettsportsindoor.com/; Acoustic performance: 21 dB; Board dimensions: -; Elongation at break: -; Friction: 80 to 110; Resistance to a rolling load: ≤ 0.50 mm; Resistance to wear: ≤ 0.25g; Shock absorption: P2 (≥35%); Specular gloss: ≤ 30; Temperature range: -; Vertical ball behaviour: ≥ 95%; Vertical deformation: P2
Classification: C3020400 Flooring (Uniformat)
Pset_CoveringCommon - TotalThickness: 8.1 mm

# IfcCovering: Sol:TARKETT - Omnisports Active+ - Coral, Sol:TARKETT - Omnisports Active+ - Coral:373786
In: Niveau 1
Type - PredefinedType: FLOORING; Material: TARKETT - Omnisports Active+ - Uni CORAL 8.1 mm
Type - Pset_ConcreteElementGeneral - FireRating: Cfl - s1
Type - Pset_CoveringCommon - Reference: TARKETT - Omnisports Active+ - Coral; FireRating: Cfl - s1
Type - Pset_ManufacturerTypeInformation - Manufacturer: TARKETT
Type - Pset_QuantityTakeOff - Reference: TARKETT - Omnisports Active+ - Coral
Type - PSet_Tarkett_EN - Underfloor heating: yes; Tensile strength: 0; Type of floorcovering: Heterogeneous indoor sports floorcoverings; Flammability: Cfl - s1; Thermal resistance: 0.12 kg/K/s3; Design: Coral; Dimension: 2m x 20.5lm; Plasticizer: Phthalate-free; Reaction to fire: Cfl - s1; Reduction of in-room impact noise: Class A (≤65dB); Residual indentation: ≤ 0.50 mm; Total mass: 4.76; Total thickness: 8.1 mm; Total VOC emissions (after 28 days): ≤ 10 μg/m³; URL: https://www.tarkettsportsindoor.com/; Acoustic performance: 21 dB; Board dimensions: -; Elongation at break: -; Friction: 80 to 110; Resistance to a rolling load: ≤ 0.50 mm; Resistance to wear: ≤ 0.25g; Shock absorption: P2 (≥35%); Specular gloss: ≤ 30; Temperature range: -; Vertical ball behaviour: ≥ 95%; Vertical deformation: P2
Classification: C3020400 Flooring (Uniformat)
Pset_CoveringCommon - TotalThickness: 8.1 mm

# IfcCovering: Sol:TARKETT - Omnisports Active+ - Dark Beech, Sol:TARKETT - Omnisports Active+ - Dark Beech:373723
In: Niveau 1
Type - PredefinedType: FLOORING; Material: TARKETT - Omnisports Active+ - Dark Beech 8.1 mm
Type - Pset_ConcreteElementGeneral - FireRating: Cfl - s1
Type - Pset_CoveringCommon - Reference: TARKETT - Omnisports Active+ - Dark Beech; FireRating: Cfl - s1
Type - Pset_ManufacturerTypeInformation - Manufacturer: TARKETT
Type - Pset_QuantityTakeOff - Reference: TARKETT - Omnisports Active+ - Dark Beech
Type - PSet_Tarkett_EN - Underfloor heating: yes; Tensile strength: 0; Type of floorcovering: Heterogeneous indoor sports floorcoverings; Flammability: Cfl - s1; Thermal resistance: 0.12 kg/K/s3; Design: Dark Beech; Dimension: 2m x 20.5lm; Plasticizer: Phthalate-free; Reaction to fire: Cfl - s1; Reduction of in-room impact noise: Class A (≤65dB); Residual indentation: ≤ 0.50 mm; Total mass: 4.76; Total thickness: 8.1 mm; Total VOC emissions (after 28 days): ≤ 10 μg/m³; URL: https://www.tarkettsportsindoor.com/; Acoustic performance: 21 dB; Board dimensions: -; Elongation at break: -; Friction: 80 to 110; Resistance to a rolling load: ≤ 0.50 mm; Resistance to wear: ≤ 0.25g; Shock absorption: P2 (≥35%); Specular gloss: ≤ 30; Temperature range: -; Vertical ball behaviour: ≥ 95%; Vertical deformation: P2
Classification: C3020400 Flooring (Uniformat)
Pset_CoveringCommon - TotalThickness: 8.1 mm

# IfcCovering: Sol:TARKETT - Omnisports Active+ - Golden Maple, Sol:TARKETT - Omnisports Active+ - Golden Maple:373732
In: Niveau 1
Type - PredefinedType: FLOORING; Material: TARKETT - Omnisports Active+ - Maple GOLDEN MAPLE 8.1 mm
Type - Pset_ConcreteElementGeneral - FireRating: Cfl - s1
Type - Pset_CoveringCommon - Reference: TARKETT - Omnisports Active+ - Golden Maple; FireRating: Cfl - s1
Type - Pset_ManufacturerTypeInformation - Manufacturer: TARKETT
Type - Pset_QuantityTakeOff - Reference: TARKETT - Omnisports Active+ - Golden Maple
Type - PSet_Tarkett_EN - Underfloor heating: yes; Tensile strength: 0; Type of floorcovering: Heterogeneous indoor sports floorcoverings; Flammability: Cfl - s1; Thermal resistance: 0.12 kg/K/s3; Design: Golden Maple; Dimension: 2m x 20.5lm; Plasticizer: Phthalate-free; Reaction to fire: Cfl - s1; Reduction of in-room impact noise: Class A (≤65dB); Residual indentation: ≤ 0.50 mm; Total mass: 4.76; Total thickness: 8.1 mm; Total VOC emissions (after 28 days): ≤ 10 μg/m³; URL: https://www.tarkettsportsindoor.com/; Acoustic performance: 21 dB; Board dimensions: -; Elongation at break: -; Friction: 80 to 110; Resistance to a rolling load: ≤ 0.50 mm; Resistance to wear: ≤ 0.25g; Shock absorption: P2 (≥35%); Specular gloss: ≤ 30; Temperature range: -; Vertical ball behaviour: ≥ 95%; Vertical deformation: P2
Classification: C3020400 Flooring (Uniformat)
Pset_CoveringCommon - TotalThickness: 8.1 mm

# IfcCovering: Sol:TARKETT - Omnisports Active+ - Grey, Sol:TARKETT - Omnisports Active+ - Grey:373795
In: Niveau 1
Type - PredefinedType: FLOORING; Material: TARKETT - Omnisports Active+ - Uni GREY 8.1 mm
Type - Pset_ConcreteElementGeneral - FireRating: Cfl - s1
Type - Pset_CoveringCommon - Reference: TARKETT - Omnisports Active+ - Grey; FireRating: Cfl - s1
Type - Pset_ManufacturerTypeInformation - Manufacturer: TARKETT
Type - Pset_QuantityTakeOff - Reference: TARKETT - Omnisports Active+ - Grey
Type - PSet_Tarkett_EN - Underfloor heating: yes; Tensile strength: 0; Type of floorcovering: Heterogeneous indoor sports floorcoverings; Flammability: Cfl - s1; Thermal resistance: 0.12 kg/K/s3; Design: Grey; Dimension: 2m x 20.5lm; Plasticizer: Phthalate-free; Reaction to fire: Cfl - s1; Reduction of in-room impact noise: Class A (≤65dB); Residual indentation: ≤ 0.50 mm; Total mass: 4.76; Total thickness: 8.1 mm; Total VOC emissions (after 28 days): ≤ 10 μg/m³; URL: https://www.tarkettsportsindoor.com/; Acoustic performance: 21 dB; Board dimensions: -; Elongation at break: -; Friction: 80 to 110; Resistance to a rolling load: ≤ 0.50 mm; Resistance to wear: ≤ 0.25g; Shock absorption: P2 (≥35%); Specular gloss: ≤ 30; Temperature range: -; Vertical ball behaviour: ≥ 95%; Vertical deformation: P2
Classification: C3020400 Flooring (Uniformat)
Pset_CoveringCommon - TotalThickness: 8.1 mm

# IfcCovering: Sol:TARKETT - Omnisports Active+ - Lagoon, Sol:TARKETT - Omnisports Active+ - Lagoon:373804
In: Niveau 1
Type - PredefinedType: FLOORING; Material: TARKETT - Omnisports Active+ - Uni LAGOON 8.1 mm
Type - Pset_ConcreteElementGeneral - FireRating: Cfl - s1
Type - Pset_CoveringCommon - Reference: TARKETT - Omnisports Active+ - Lagoon; FireRating: Cfl - s1
Type - Pset_ManufacturerTypeInformation - Manufacturer: TARKETT
Type - Pset_QuantityTakeOff - Reference: TARKETT - Omnisports Active+ - Lagoon
Type - PSet_Tarkett_EN - Underfloor heating: yes; Tensile strength: 0; Type of floorcovering: Heterogeneous indoor sports floorcoverings; Flammability: Cfl - s1; Thermal resistance: 0.12 kg/K/s3; Design: Lagoon; Dimension: 2m x 20.5lm; Plasticizer: Phthalate-free; Reaction to fire: Cfl - s1; Reduction of in-room impact noise: Class A (≤65dB); Residual indentation: ≤ 0.50 mm; Total mass: 4.76; Total thickness: 8.1 mm; Total VOC emissions (after 28 days): ≤ 10 μg/m³; URL: https://www.tarkettsportsindoor.com/; Acoustic performance: 21 dB; Board dimensions: -; Elongation at break: -; Friction: 80 to 110; Resistance to a rolling load: ≤ 0.50 mm; Resistance to wear: ≤ 0.25g; Shock absorption: P2 (≥35%); Specular gloss: ≤ 30; Temperature range: -; Vertical ball behaviour: ≥ 95%; Vertical deformation: P2
Classification: C3020400 Flooring (Uniformat)
Pset_CoveringCommon - TotalThickness: 8.1 mm

# IfcCovering: Sol:TARKETT - Omnisports Active+ - Light Green, Sol:TARKETT - Omnisports Active+ - Light Green:373813
In: Niveau 1
Type - PredefinedType: FLOORING; Material: TARKETT - Omnisports Active+ - Uni LIGHT GREEN 8.1 mm
Type - Pset_ConcreteElementGeneral - FireRating: Cfl - s1
Type - Pset_CoveringCommon - Reference: TARKETT - Omnisports Active+ - Light Green; FireRating: Cfl - s1
Type - Pset_ManufacturerTypeInformation - Manufacturer: TARKETT
Type - Pset_QuantityTakeOff - Reference: TARKETT - Omnisports Active+ - Light Green
Type - PSet_Tarkett_EN - Underfloor heating: yes; Tensile strength: 0; Type of floorcovering: Heterogeneous indoor sports floorcoverings; Flammability: Cfl - s1; Thermal resistance: 0.12 kg/K/s3; Design: Light Green; Dimension: 2m x 20.5lm; Plasticizer: Phthalate-free; Reaction to fire: Cfl - s1; Reduction of in-room impact noise: Class A (≤65dB); Residual indentation: ≤ 0.50 mm; Total mass: 4.76; Total thickness: 8.1 mm; Total VOC emissions (after 28 days): ≤ 10 μg/m³; URL: https://www.tarkettsportsindoor.com/; Acoustic performance: 21 dB; Board dimensions: -; Elongation at break: -; Friction: 80 to 110; Resistance to a rolling load: ≤ 0.50 mm; Resistance to wear: ≤ 0.25g; Shock absorption: P2 (≥35%); Specular gloss: ≤ 30; Temperature range: -; Vertical ball behaviour: ≥ 95%; Vertical deformation: P2
Classification: C3020400 Flooring (Uniformat)
Pset_CoveringCommon - TotalThickness: 8.1 mm

# IfcCovering: Sol:TARKETT - Omnisports Active+ - Light Maple, Sol:TARKETT - Omnisports Active+ - Light Maple:373750
In: Niveau 1
Type - PredefinedType: FLOORING; Material: TARKETT - Omnisports Active+ - Maple LIGHT MAPLE 8.1 mm
Type - Pset_ConcreteElementGeneral - FireRating: Cfl - s1
Type - Pset_CoveringCommon - Reference: TARKETT - Omnisports Active+ - Light Maple; FireRating: Cfl - s1
Type - Pset_ManufacturerTypeInformation - Manufacturer: TARKETT
Type - Pset_QuantityTakeOff - Reference: TARKETT - Omnisports Active+ - Light Maple
Type - PSet_Tarkett_EN - Underfloor heating: yes; Tensile strength: 0; Type of floorcovering: Heterogeneous indoor sports floorcoverings; Flammability: Cfl - s1; Thermal resistance: 0.12 kg/K/s3; Design: Light Maple; Dimension: 2m x 20.5lm; Plasticizer: Phthalate-free; Reaction to fire: Cfl - s1; Reduction of in-room impact noise: Class A (≤65dB); Residual indentation: ≤ 0.50 mm; Total mass: 4.76; Total thickness: 8.1 mm; Total VOC emissions (after 28 days): ≤ 10 μg/m³; URL: https://www.tarkettsportsindoor.com/; Acoustic performance: 21 dB; Board dimensions: -; Elongation at break: -; Friction: 80 to 110; Resistance to a rolling load: ≤ 0.50 mm; Resistance to wear: ≤ 0.25g; Shock absorption: P2 (≥35%); Specular gloss: ≤ 30; Temperature range: -; Vertical ball behaviour: ≥ 95%; Vertical deformation: P2
Classification: C3020400 Flooring (Uniformat)
Pset_CoveringCommon - TotalThickness: 8.1 mm

# IfcCovering: Sol:TARKETT - Omnisports Active+ - Lime, Sol:TARKETT - Omnisports Active+ - Lime:373822
In: Niveau 1
Type - PredefinedType: FLOORING; Material: TARKETT - Omnisports Active+ - Uni LIME 8.1 mm
Type - Pset_ConcreteElementGeneral - FireRating: Cfl - s1
Type - Pset_CoveringCommon - Reference: TARKETT - Omnisports Active+ - Lime; FireRating: Cfl - s1
Type - Pset_ManufacturerTypeInformation - Manufacturer: TARKETT
Type - Pset_QuantityTakeOff - Reference: TARKETT - Omnisports Active+ - Lime
Type - PSet_Tarkett_EN - Underfloor heating: yes; Tensile strength: 0; Type of floorcovering: Heterogeneous indoor sports floorcoverings; Flammability: Cfl - s1; Thermal resistance: 0.12 kg/K/s3; Design: Lime; Dimension: 2m x 20.5lm; Plasticizer: Phthalate-free; Reaction to fire: Cfl - s1; Reduction of in-room impact noise: Class A (≤65dB); Residual indentation: ≤ 0.50 mm; Total mass: 4.76; Total thickness: 8.1 mm; Total VOC emissions (after 28 days): ≤ 10 μg/m³; URL: https://www.tarkettsportsindoor.com/; Acoustic performance: 21 dB; Board dimensions: -; Elongation at break: -; Friction: 80 to 110; Resistance to a rolling load: ≤ 0.50 mm; Resistance to wear: ≤ 0.25g; Shock absorption: P2 (≥35%); Specular gloss: ≤ 30; Temperature range: -; Vertical ball behaviour: ≥ 95%; Vertical deformation: P2
Classification: C3020400 Flooring (Uniformat)
Pset_CoveringCommon - TotalThickness: 8.1 mm

# IfcCovering: Sol:TARKETT - Omnisports Active+ - Magenta, Sol:TARKETT - Omnisports Active+ - Magenta:373831
In: Niveau 1
Type - PredefinedType: FLOORING; Material: TARKETT - Omnisports Active+ - Uni MAGENTA 8.1 mm
Type - Pset_ConcreteElementGeneral - FireRating: Cfl - s1
Type - Pset_CoveringCommon - Reference: TARKETT - Omnisports Active+ - Magenta; FireRating: Cfl - s1
Type - Pset_ManufacturerTypeInformation - Manufacturer: TARKETT
Type - Pset_QuantityTakeOff - Reference: TARKETT - Omnisports Active+ - Magenta
Type - PSet_Tarkett_EN - Underfloor heating: yes; Tensile strength: 0; Type of floorcovering: Heterogeneous indoor sports floorcoverings; Flammability: Cfl - s1; Thermal resistance: 0.12 kg/K/s3; Design: Magenta; Dimension: 2m x 20.5lm; Plasticizer: Phthalate-free; Reaction to fire: Cfl - s1; Reduction of in-room impact noise: Class A (≤65dB); Residual indentation: ≤ 0.50 mm; Total mass: 4.76; Total thickness: 8.1 mm; Total VOC emissions (after 28 days): ≤ 10 μg/m³; URL: https://www.tarkettsportsindoor.com/; Acoustic performance: 21 dB; Board dimensions: -; Elongation at break: -; Friction: 80 to 110; Resistance to a rolling load: ≤ 0.50 mm; Resistance to wear: ≤ 0.25g; Shock absorption: P2 (≥35%); Specular gloss: ≤ 30; Temperature range: -; Vertical ball behaviour: ≥ 95%; Vertical deformation: P2
Classification: C3020400 Flooring (Uniformat)
Pset_CoveringCommon - TotalThickness: 8.1 mm

# IfcCovering: Sol:TARKETT - Omnisports Active+ - Maple Grey, Sol:TARKETT - Omnisports Active+ - Maple Grey:373741
In: Niveau 1
Type - PredefinedType: FLOORING; Material: TARKETT - Omnisports Active+ - Maple GREY 8.1 mm
Type - Pset_ConcreteElementGeneral - FireRating: Cfl - s1
Type - Pset_CoveringCommon - Reference: TARKETT - Omnisports Active+ - Maple Grey; FireRating: Cfl - s1
Type - Pset_ManufacturerTypeInformation - Manufacturer: TARKETT
Type - Pset_QuantityTakeOff - Reference: TARKETT - Omnisports Active+ - Maple Grey
Type - PSet_Tarkett_EN - Underfloor heating: yes; Tensile strength: 0; Type of floorcovering: Heterogeneous indoor sports floorcoverings; Flammability: Cfl - s1; Thermal resistance: 0.12 kg/K/s3; Design: Maple Grey; Dimension: 2m x 20.5lm; Plasticizer: Phthalate-free; Reaction to fire: Cfl - s1; Reduction of in-room impact noise: Class A (≤65dB); Residual indentation: ≤ 0.50 mm; Total mass: 4.76; Total thickness: 8.1 mm; Total VOC emissions (after 28 days): ≤ 10 μg/m³; URL: https://www.tarkettsportsindoor.com/; Acoustic performance: 21 dB; Board dimensions: -; Elongation at break: -; Friction: 80 to 110; Resistance to a rolling load: ≤ 0.50 mm; Resistance to wear: ≤ 0.25g; Shock absorption: P2 (≥35%); Specular gloss: ≤ 30; Temperature range: -; Vertical ball behaviour: ≥ 95%; Vertical deformation: P2
Classification: C3020400 Flooring (Uniformat)
Pset_CoveringCommon - TotalThickness: 8.1 mm

# IfcCovering: Sol:TARKETT - Omnisports Active+ - Maple Red, Sol:TARKETT - Omnisports Active+ - Maple Red:373759
In: Niveau 1
Type - PredefinedType: FLOORING; Material: TARKETT - Omnisports Active+ - Maple RED 8.1 mm
Type - Pset_ConcreteElementGeneral - FireRating: Cfl - s1
Type - Pset_CoveringCommon - Reference: TARKETT - Omnisports Active+ - Maple Red; FireRating: Cfl - s1
Type - Pset_ManufacturerTypeInformation - Manufacturer: TARKETT
Type - Pset_QuantityTakeOff - Reference: TARKETT - Omnisports Active+ - Maple Red
Type - PSet_Tarkett_EN - Underfloor heating: yes; Tensile strength: 0; Type of floorcovering: Heterogeneous indoor sports floorcoverings; Flammability: Cfl - s1; Thermal resistance: 0.12 kg/K/s3; Design: Maple Red; Dimension: 2m x 20.5lm; Plasticizer: Phthalate-free; Reaction to fire: Cfl - s1; Reduction of in-room impact noise: Class A (≤65dB); Residual indentation: ≤ 0.50 mm; Total mass: 4.76; Total thickness: 8.1 mm; Total VOC emissions (after 28 days): ≤ 10 μg/m³; URL: https://www.tarkettsportsindoor.com/; Acoustic performance: 21 dB; Board dimensions: -; Elongation at break: -; Friction: 80 to 110; Resistance to a rolling load: ≤ 0.50 mm; Resistance to wear: ≤ 0.25g; Shock absorption: P2 (≥35%); Specular gloss: ≤ 30; Temperature range: -; Vertical ball behaviour: ≥ 95%; Vertical deformation: P2
Classification: C3020400 Flooring (Uniformat)
Pset_CoveringCommon - TotalThickness: 8.1 mm

# IfcCovering: Sol:TARKETT - Omnisports Active+ - Maple Sky Blue, Sol:TARKETT - Omnisports Active+ - Maple Sky Blue:373768
In: Niveau 1
Type - PredefinedType: FLOORING; Material: TARKETT - Omnisports Active+ - Maple SKY BLUE 8.1 mm
Type - Pset_ConcreteElementGeneral - FireRating: Cfl - s1
Type - Pset_CoveringCommon - Reference: TARKETT - Omnisports Active+ - Maple Sky Blue; FireRating: Cfl - s1
Type - Pset_ManufacturerTypeInformation - Manufacturer: TARKETT
Type - Pset_QuantityTakeOff - Reference: TARKETT - Omnisports Active+ - Maple Sky Blue
Type - PSet_Tarkett_EN - Underfloor heating: yes; Tensile strength: 0; Type of floorcovering: Heterogeneous indoor sports floorcoverings; Flammability: Cfl - s1; Thermal resistance: 0.12 kg/K/s3; Design: Maple Sky Blue; Dimension: 2m x 20.5lm; Plasticizer: Phthalate-free; Reaction to fire: Cfl - s1; Reduction of in-room impact noise: Class A (≤65dB); Residual indentation: ≤ 0.50 mm; Total mass: 4.76; Total thickness: 8.1 mm; Total VOC emissions (after 28 days): ≤ 10 μg/m³; URL: https://www.tarkettsportsindoor.com/; Acoustic performance: 21 dB; Board dimensions: -; Elongation at break: -; Friction: 80 to 110; Resistance to a rolling load: ≤ 0.50 mm; Resistance to wear: ≤ 0.25g; Shock absorption: P2 (≥35%); Specular gloss: ≤ 30; Temperature range: -; Vertical ball behaviour: ≥ 95%; Vertical deformation: P2
Classification: C3020400 Flooring (Uniformat)
Pset_CoveringCommon - TotalThickness: 8.1 mm

# IfcCovering: Sol:TARKETT - Omnisports Active+ - Mint Green, Sol:TARKETT - Omnisports Active+ - Mint Green:373840
In: Niveau 1
Type - PredefinedType: FLOORING; Material: TARKETT - Omnisports Active+ - Uni MINT GREEN 8.1 mm
Type - Pset_ConcreteElementGeneral - FireRating: Cfl - s1
Type - Pset_CoveringCommon - Reference: TARKETT - Omnisports Active+ - Mint Green; FireRating: Cfl - s1
Type - Pset_ManufacturerTypeInformation - Manufacturer: TARKETT
Type - Pset_QuantityTakeOff - Reference: TARKETT - Omnisports Active+ - Mint Green
Type - PSet_Tarkett_EN - Underfloor heating: yes; Tensile strength: 0; Type of floorcovering: Heterogeneous indoor sports floorcoverings; Flammability: Cfl - s1; Thermal resistance: 0.12 kg/K/s3; Design: Mint Green; Dimension: 2m x 20.5lm; Plasticizer: Phthalate-free; Reaction to fire: Cfl - s1; Reduction of in-room impact noise: Class A (≤65dB); Residual indentation: ≤ 0.50 mm; Total mass: 4.76; Total thickness: 8.1 mm; Total VOC emissions (after 28 days): ≤ 10 μg/m³; URL: https://www.tarkettsportsindoor.com/; Acoustic performance: 21 dB; Board dimensions: -; Elongation at break: -; Friction: 80 to 110; Resistance to a rolling load: ≤ 0.50 mm; Resistance to wear: ≤ 0.25g; Shock absorption: P2 (≥35%); Specular gloss: ≤ 30; Temperature range: -; Vertical ball behaviour: ≥ 95%; Vertical deformation: P2
Classification: C3020400 Flooring (Uniformat)
Pset_CoveringCommon - TotalThickness: 8.1 mm

# IfcCovering: Sol:TARKETT - Omnisports Active+ - Night Blue, Sol:TARKETT - Omnisports Active+ - Night Blue:373849
In: Niveau 1
Type - PredefinedType: FLOORING; Material: TARKETT - Omnisports Active+ - Uni NIGHT BLUE 8.1 mm
Type - Pset_ConcreteElementGeneral - FireRating: Cfl - s1
Type - Pset_CoveringCommon - Reference: TARKETT - Omnisports Active+ - Night Blue; FireRating: Cfl - s1
Type - Pset_ManufacturerTypeInformation - Manufacturer: TARKETT
Type - Pset_QuantityTakeOff - Reference: TARKETT - Omnisports Active+ - Night Blue
Type - PSet_Tarkett_EN - Underfloor heating: yes; Tensile strength: 0; Type of floorcovering: Heterogeneous indoor sports floorcoverings; Flammability: Cfl - s1; Thermal resistance: 0.12 kg/K/s3; Design: Night Blue; Dimension: 2m x 20.5lm; Plasticizer: Phthalate-free; Reaction to fire: Cfl - s1; Reduction of in-room impact noise: Class A (≤65dB); Residual indentation: ≤ 0.50 mm; Total mass: 4.76; Total thickness: 8.1 mm; Total VOC emissions (after 28 days): ≤ 10 μg/m³; URL: https://www.tarkettsportsindoor.com/; Acoustic performance: 21 dB; Board dimensions: -; Elongation at break: -; Friction: 80 to 110; Resistance to a rolling load: ≤ 0.50 mm; Resistance to wear: ≤ 0.25g; Shock absorption: P2 (≥35%); Specular gloss: ≤ 30; Temperature range: -; Vertical ball behaviour: ≥ 95%; Vertical deformation: P2
Classification: C3020400 Flooring (Uniformat)
Pset_CoveringCommon - TotalThickness: 8.1 mm

# IfcCovering: Sol:TARKETT - Omnisports Active+ - Orange, Sol:TARKETT - Omnisports Active+ - Orange:373858
In: Niveau 1
Type - PredefinedType: FLOORING; Material: TARKETT - Omnisports Active+ - Uni ORANGE 8.1 mm
Type - Pset_ConcreteElementGeneral - FireRating: Cfl - s1
Type - Pset_CoveringCommon - Reference: TARKETT - Omnisports Active+ - Orange; FireRating: Cfl - s1
Type - Pset_ManufacturerTypeInformation - Manufacturer: TARKETT
Type - Pset_QuantityTakeOff - Reference: TARKETT - Omnisports Active+ - Orange
Type - PSet_Tarkett_EN - Underfloor heating: yes; Tensile strength: 0; Type of floorcovering: Heterogeneous indoor sports floorcoverings; Flammability: Cfl - s1; Thermal resistance: 0.12 kg/K/s3; Design: Orange; Dimension: 2m x 20.5lm; Plasticizer: Phthalate-free; Reaction to fire: Cfl - s1; Reduction of in-room impact noise: Class A (≤65dB); Residual indentation: ≤ 0.50 mm; Total mass: 4.76; Total thickness: 8.1 mm; Total VOC emissions (after 28 days): ≤ 10 μg/m³; URL: https://www.tarkettsportsindoor.com/; Acoustic performance: 21 dB; Board dimensions: -; Elongation at break: -; Friction: 80 to 110; Resistance to a rolling load: ≤ 0.50 mm; Resistance to wear: ≤ 0.25g; Shock absorption: P2 (≥35%); Specular gloss: ≤ 30; Temperature range: -; Vertical ball behaviour: ≥ 95%; Vertical deformation: P2
Classification: C3020400 Flooring (Uniformat)
Pset_CoveringCommon - TotalThickness: 8.1 mm

# IfcCovering: Sol:TARKETT - Omnisports Active+ - Purple, Sol:TARKETT - Omnisports Active+ - Purple:373867
In: Niveau 1
Type - PredefinedType: FLOORING; Material: TARKETT - Omnisports Active+ - Uni PURPLE 8.1 mm
Type - Pset_ConcreteElementGeneral - FireRating: Cfl - s1
Type - Pset_CoveringCommon - Reference: TARKETT - Omnisports Active+ - Purple; FireRating: Cfl - s1
Type - Pset_ManufacturerTypeInformation - Manufacturer: TARKETT
Type - Pset_QuantityTakeOff - Reference: TARKETT - Omnisports Active+ - Purple
Type - PSet_Tarkett_EN - Underfloor heating: yes; Tensile strength: 0; Type of floorcovering: Heterogeneous indoor sports floorcoverings; Flammability: Cfl - s1; Thermal resistance: 0.12 kg/K/s3; Design: Purple; Dimension: 2m x 20.5lm; Plasticizer: Phthalate-free; Reaction to fire: Cfl - s1; Reduction of in-room impact noise: Class A (≤65dB); Residual indentation: ≤ 0.50 mm; Total mass: 4.76; Total thickness: 8.1 mm; Total VOC emissions (after 28 days): ≤ 10 μg/m³; URL: https://www.tarkettsportsindoor.com/; Acoustic performance: 21 dB; Board dimensions: -; Elongation at break: -; Friction: 80 to 110; Resistance to a rolling load: ≤ 0.50 mm; Resistance to wear: ≤ 0.25g; Shock absorption: P2 (≥35%); Specular gloss: ≤ 30; Temperature range: -; Vertical ball behaviour: ≥ 95%; Vertical deformation: P2
Classification: C3020400 Flooring (Uniformat)
Pset_CoveringCommon - TotalThickness: 8.1 mm

# IfcCovering: Sol:TARKETT - Omnisports Active+ - Red, Sol:TARKETT - Omnisports Active+ - Red:373876
In: Niveau 1
Type - PredefinedType: FLOORING; Material: TARKETT - Omnisports Active+ - Uni RED 8.1 mm
Type - Pset_ConcreteElementGeneral - FireRating: Cfl - s1
Type - Pset_CoveringCommon - Reference: TARKETT - Omnisports Active+ - Red; FireRating: Cfl - s1
Type - Pset_ManufacturerTypeInformation - Manufacturer: TARKETT
Type - Pset_QuantityTakeOff - Reference: TARKETT - Omnisports Active+ - Red
Type - PSet_Tarkett_EN - Underfloor heating: yes; Tensile strength: 0; Type of floorcovering: Heterogeneous indoor sports floorcoverings; Flammability: Cfl - s1; Thermal resistance: 0.12 kg/K/s3; Design: Red; Dimension: 2m x 20.5lm; Plasticizer: Phthalate-free; Reaction to fire: Cfl - s1; Reduction of in-room impact noise: Class A (≤65dB); Residual indentation: ≤ 0.50 mm; Total mass: 4.76; Total thickness: 8.1 mm; Total VOC emissions (after 28 days): ≤ 10 μg/m³; URL: https://www.tarkettsportsindoor.com/; Acoustic performance: 21 dB; Board dimensions: -; Elongation at break: -; Friction: 80 to 110; Resistance to a rolling load: ≤ 0.50 mm; Resistance to wear: ≤ 0.25g; Shock absorption: P2 (≥35%); Specular gloss: ≤ 30; Temperature range: -; Vertical ball behaviour: ≥ 95%; Vertical deformation: P2
Classification: C3020400 Flooring (Uniformat)
Pset_CoveringCommon - TotalThickness: 8.1 mm

# IfcCovering: Sol:TARKETT - Omnisports Active+ - Royal Blue, Sol:TARKETT - Omnisports Active+ - Royal Blue:373885
In: Niveau 1
Type - PredefinedType: FLOORING; Material: TARKETT - Omnisports Active+ - Uni ROYAL BLUE 8.1 mm
Type - Pset_ConcreteElementGeneral - FireRating: Cfl - s1
Type - Pset_CoveringCommon - Reference: TARKETT - Omnisports Active+ - Royal Blue; FireRating: Cfl - s1
Type - Pset_ManufacturerTypeInformation - Manufacturer: TARKETT
Type - Pset_QuantityTakeOff - Reference: TARKETT - Omnisports Active+ - Royal Blue
Type - PSet_Tarkett_EN - Underfloor heating: yes; Tensile strength: 0; Type of floorcovering: Heterogeneous indoor sports floorcoverings; Flammability: Cfl - s1; Thermal resistance: 0.12 kg/K/s3; Design: Royal Blue; Dimension: 2m x 20.5lm; Plasticizer: Phthalate-free; Reaction to fire: Cfl - s1; Reduction of in-room impact noise: Class A (≤65dB); Residual indentation: ≤ 0.50 mm; Total mass: 4.76; Total thickness: 8.1 mm; Total VOC emissions (after 28 days): ≤ 10 μg/m³; URL: https://www.tarkettsportsindoor.com/; Acoustic performance: 21 dB; Board dimensions: -; Elongation at break: -; Friction: 80 to 110; Resistance to a rolling load: ≤ 0.50 mm; Resistance to wear: ≤ 0.25g; Shock absorption: P2 (≥35%); Specular gloss: ≤ 30; Temperature range: -; Vertical ball behaviour: ≥ 95%; Vertical deformation: P2
Classification: C3020400 Flooring (Uniformat)
Pset_CoveringCommon - TotalThickness: 8.1 mm

# IfcCovering: Sol:TARKETT - Omnisports Active+ - Sky Blue, Sol:TARKETT - Omnisports Active+ - Sky Blue:373894
In: Niveau 1
Type - PredefinedType: FLOORING; Material: TARKETT - Omnisports Active+ - Uni SKY BLUE 8.1 mm
Type - Pset_ConcreteElementGeneral - FireRating: Cfl - s1
Type - Pset_CoveringCommon - Reference: TARKETT - Omnisports Active+ - Sky Blue; FireRating: Cfl - s1
Type - Pset_ManufacturerTypeInformation - Manufacturer: TARKETT
Type - Pset_QuantityTakeOff - Reference: TARKETT - Omnisports Active+ - Sky Blue
Type - PSet_Tarkett_EN - Underfloor heating: yes; Tensile strength: 0; Type of floorcovering: Heterogeneous indoor sports floorcoverings; Flammability: Cfl - s1; Thermal resistance: 0.12 kg/K/s3; Design: Sky Blue; Dimension: 2m x 20.5lm; Plasticizer: Phthalate-free; Reaction to fire: Cfl - s1; Reduction of in-room impact noise: Class A (≤65dB); Residual indentation: ≤ 0.50 mm; Total mass: 4.76; Total thickness: 8.1 mm; Total VOC emissions (after 28 days): ≤ 10 μg/m³; URL: https://www.tarkettsportsindoor.com/; Acoustic performance: 21 dB; Board dimensions: -; Elongation at break: -; Friction: 80 to 110; Resistance to a rolling load: ≤ 0.50 mm; Resistance to wear: ≤ 0.25g; Shock absorption: P2 (≥35%); Specular gloss: ≤ 30; Temperature range: -; Vertical ball behaviour: ≥ 95%; Vertical deformation: P2
Classification: C3020400 Flooring (Uniformat)
Pset_CoveringCommon - TotalThickness: 8.1 mm

# IfcCovering: Sol:TARKETT - Omnisports Active+ - Teal, Sol:TARKETT - Omnisports Active+ - Teal:373903
In: Niveau 1
Type - PredefinedType: FLOORING; Material: TARKETT - Omnisports Active+ - Uni TEAL 8.1 mm
Type - Pset_ConcreteElementGeneral - FireRating: Cfl - s1
Type - Pset_CoveringCommon - Reference: TARKETT - Omnisports Active+ - Teal; FireRating: Cfl - s1
Type - Pset_ManufacturerTypeInformation - Manufacturer: TARKETT
Type - Pset_QuantityTakeOff - Reference: TARKETT - Omnisports Active+ - Teal
Type - PSet_Tarkett_EN - Underfloor heating: yes; Tensile strength: 0; Type of floorcovering: Heterogeneous indoor sports floorcoverings; Flammability: Cfl - s1; Thermal resistance: 0.12 kg/K/s3; Design: Teal; Dimension: 2m x 20.5lm; Plasticizer: Phthalate-free; Reaction to fire: Cfl - s1; Reduction of in-room impact noise: Class A (≤65dB); Residual indentation: ≤ 0.50 mm; Total mass: 4.76; Total thickness: 8.1 mm; Total VOC emissions (after 28 days): ≤ 10 μg/m³; URL: https://www.tarkettsportsindoor.com/; Acoustic performance: 21 dB; Board dimensions: -; Elongation at break: -; Friction: 80 to 110; Resistance to a rolling load: ≤ 0.50 mm; Resistance to wear: ≤ 0.25g; Shock absorption: P2 (≥35%); Specular gloss: ≤ 30; Temperature range: -; Vertical ball behaviour: ≥ 95%; Vertical deformation: P2
Classification: C3020400 Flooring (Uniformat)
Pset_CoveringCommon - TotalThickness: 8.1 mm

# IfcCovering: Sol:TARKETT - Omnisports Active+ - Yellow, Sol:TARKETT - Omnisports Active+ - Yellow:373912
In: Niveau 1
Type - PredefinedType: FLOORING; Material: TARKETT - Omnisports Active+ - Uni YELLOW 8.1 mm
Type - Pset_ConcreteElementGeneral - FireRating: Cfl - s1
Type - Pset_CoveringCommon - Reference: TARKETT - Omnisports Active+ - Yellow; FireRating: Cfl - s1
Type - Pset_ManufacturerTypeInformation - Manufacturer: TARKETT
Type - Pset_QuantityTakeOff - Reference: TARKETT - Omnisports Active+ - Yellow
Type - PSet_Tarkett_EN - Underfloor heating: yes; Tensile strength: 0; Type of floorcovering: Heterogeneous indoor sports floorcoverings; Flammability: Cfl - s1; Thermal resistance: 0.12 kg/K/s3; Design: Yellow; Dimension: 2m x 20.5lm; Plasticizer: Phthalate-free; Reaction to fire: Cfl - s1; Reduction of in-room impact noise: Class A (≤65dB); Residual indentation: ≤ 0.50 mm; Total mass: 4.76; Total thickness: 8.1 mm; Total VOC emissions (after 28 days): ≤ 10 μg/m³; URL: https://www.tarkettsportsindoor.com/; Acoustic performance: 21 dB; Board dimensions: -; Elongation at break: -; Friction: 80 to 110; Resistance to a rolling load: ≤ 0.50 mm; Resistance to wear: ≤ 0.25g; Shock absorption: P2 (≥35%); Specular gloss: ≤ 30; Temperature range: -; Vertical ball behaviour: ≥ 95%; Vertical deformation: P2
Classification: C3020400 Flooring (Uniformat)
Pset_CoveringCommon - TotalThickness: 8.1 mm
