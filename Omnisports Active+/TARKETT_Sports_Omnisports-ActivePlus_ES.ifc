Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Numéro du projet
Time: 2021-12-21T23:17:45
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190510_1515(x64) - Exporter 18.4.0.0 - Interface alternative d'export 18.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Dec 21 23:17:45 2021 * Host: SWIFT * Database: C:\Users\MFBIM~1\AppData\Local\Temp\{FC2D1C6E-856E-4E6D-9F0E-70DE23F598E5}\ifc * Database version: 5507 * Database creation date: Tue Dec 21 23:17:43 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Dec 21 23:17:44 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Dec 21 23:17:44 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Numéro du projet
LongName: Nom du projet; Phase: Etat du projet

# IfcSite, Default
RefLatitude: 42, 12, 46, 804504; RefLongitude: -71, -2, 0, -602416; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey: Niveau:Pointe 8 mm, Niveau 1
LongName: Niveau 1; Elevation: 0 mm

# IfcBuildingElementProxy: Logo, TARKETT Sports - Logo:Logo:475882
In: Niveau 1
Type - Material: TARKETT - Logo - Bleu
Type - Pset_BuildingElementProxyCommon - Reference: Logo
Type - Pset_QuantityTakeOff - Reference: Logo
Pset_BuildingElementProxyCommon - sets with these values: 2

# IfcBuildingElementProxy: Texte 3D:600mm Arial, Texte 3D:600mm Arial:370015
In: Niveau 1
Pset_BuildingElementProxyCommon - Reference: 600mm Arial; sets with these values: 2

# IfcBuildingElementProxy: Texte 3D:80mm Arial (24)
In: Niveau 1
Pset_BuildingElementProxyCommon - Reference: 80mm Arial; sets with these values: 2
Name (Texte 3D:80mm Arial:...)
473043
473044
473045
473046
473047
473048
473049
473050
473051
473052
473053
473054
473055
473056
473057
473058
473059
473060
473061
473062
473063
473064
473065
473066

# IfcCovering: Sol:TARKETT - Omnisports Active+ - Beech, Sol:TARKETT - Omnisports Active+ - Beech:373705
In: Niveau 1
Type - PredefinedType: FLOORING; Material: TARKETT - Omnisports Active+ - Beech 8.1 mm
Type - Pset_ConcreteElementGeneral - FireRating: Cfl - s1
Type - Pset_CoveringCommon - Reference: TARKETT - Omnisports Active+ - Beech; FireRating: Cfl - s1
Type - Pset_ManufacturerTypeInformation - Manufacturer: TARKETT
Type - Pset_QuantityTakeOff - Reference: TARKETT - Omnisports Active+ - Beech
Type - PSet_Tarkett_ES - Calefacción radiante: yes; Resistencia a la tracción: 0; Tipo de pavimento: Pavimento deportivo de interior en vinilo heterogéneo; Inflamabilidad: Cfl - s1; Resistencia térmica: 0.12 kg/K/s3; Design: Beech; Formato: 2m x 20.5lm; Plastificante: Libre de ftalatos; Reacción al fuego: Cfl - s1; Absorción acústica: Clase A (≤65dB); Punzonamiento estático: ≤ 0.50 mm; Peso total: 4.76; Espesor total: 8.1 mm; Emisiones COV tras 28 días: ≤ 10 μg/m³; URL: https://www.tarkettsportsindoor.com/; Abrasion: ≤ 0.25g; Absorción de impacto: P2 (≥35%); Alargamiento a la rotura: -; Brillo especular: ≤ 30; Coeficiente de fricción: 80 a 110; Deformación vertical: P2; Dimensiones de las tablas: -; Rango de temperatura: -; Rebote del Balón: ≥ 95%; Rendimiento acústico: 21 dB; Resistencia a cargas rodantes: ≤ 0.50 mm
Classification: C3020400 Flooring (Uniformat)
Pset_CoveringCommon - TotalThickness: 8.1 mm

# IfcCovering: Sol:TARKETT - Omnisports Active+ - Black, Sol:TARKETT - Omnisports Active+ - Black:373777
In: Niveau 1
Type - PredefinedType: FLOORING; Material: TARKETT - Omnisports Active+ - Uni BLACK 8.1 mm
Type - Pset_ConcreteElementGeneral - FireRating: Cfl - s1
Type - Pset_CoveringCommon - Reference: TARKETT - Omnisports Active+ - Black; FireRating: Cfl - s1
Type - Pset_ManufacturerTypeInformation - Manufacturer: TARKETT
Type - Pset_QuantityTakeOff - Reference: TARKETT - Omnisports Active+ - Black
Type - PSet_Tarkett_ES - Calefacción radiante: yes; Resistencia a la tracción: 0; Tipo de pavimento: Pavimento deportivo de interior en vinilo heterogéneo; Inflamabilidad: Cfl - s1; Resistencia térmica: 0.12 kg/K/s3; Design: Black; Formato: 2m x 20.5lm; Plastificante: Libre de ftalatos; Reacción al fuego: Cfl - s1; Absorción acústica: Clase A (≤65dB); Punzonamiento estático: ≤ 0.50 mm; Peso total: 4.76; Espesor total: 8.1 mm; Emisiones COV tras 28 días: ≤ 10 μg/m³; URL: https://www.tarkettsportsindoor.com/; Abrasion: ≤ 0.25g; Absorción de impacto: P2 (≥35%); Alargamiento a la rotura: -; Brillo especular: ≤ 30; Coeficiente de fricción: 80 a 110; Deformación vertical: P2; Dimensiones de las tablas: -; Rango de temperatura: -; Rebote del Balón: ≥ 95%; Rendimiento acústico: 21 dB; Resistencia a cargas rodantes: ≤ 0.50 mm
Classification: C3020400 Flooring (Uniformat)
Pset_CoveringCommon - TotalThickness: 8.1 mm

# IfcCovering: Sol:TARKETT - Omnisports Active+ - Classic Oak, Sol:TARKETT - Omnisports Active+ - Classic Oak:373714
In: Niveau 1
Type - PredefinedType: FLOORING; Material: TARKETT - Omnisports Active+ - Classic Oak 8.1 mm
Type - Pset_ConcreteElementGeneral - FireRating: Cfl - s1
Type - Pset_CoveringCommon - Reference: TARKETT - Omnisports Active+ - Classic Oak; FireRating: Cfl - s1
Type - Pset_ManufacturerTypeInformation - Manufacturer: TARKETT
Type - Pset_QuantityTakeOff - Reference: TARKETT - Omnisports Active+ - Classic Oak
Type - PSet_Tarkett_ES - Calefacción radiante: yes; Resistencia a la tracción: 0; Tipo de pavimento: Pavimento deportivo de interior en vinilo heterogéneo; Inflamabilidad: Cfl - s1; Resistencia térmica: 0.12 kg/K/s3; Design: Classic Oak; Formato: 2m x 20.5lm; Plastificante: Libre de ftalatos; Reacción al fuego: Cfl - s1; Absorción acústica: Clase A (≤65dB); Punzonamiento estático: ≤ 0.50 mm; Peso total: 4.76; Espesor total: 8.1 mm; Emisiones COV tras 28 días: ≤ 10 μg/m³; URL: https://www.tarkettsportsindoor.com/; Abrasion: ≤ 0.25g; Absorción de impacto: P2 (≥35%); Alargamiento a la rotura: -; Brillo especular: ≤ 30; Coeficiente de fricción: 80 a 110; Deformación vertical: P2; Dimensiones de las tablas: -; Rango de temperatura: -; Rebote del Balón: ≥ 95%; Rendimiento acústico: 21 dB; Resistencia a cargas rodantes: ≤ 0.50 mm
Classification: C3020400 Flooring (Uniformat)
Pset_CoveringCommon - TotalThickness: 8.1 mm

# IfcCovering: Sol:TARKETT - Omnisports Active+ - Coral, Sol:TARKETT - Omnisports Active+ - Coral:373786
In: Niveau 1
Type - PredefinedType: FLOORING; Material: TARKETT - Omnisports Active+ - Uni CORAL 8.1 mm
Type - Pset_ConcreteElementGeneral - FireRating: Cfl - s1
Type - Pset_CoveringCommon - Reference: TARKETT - Omnisports Active+ - Coral; FireRating: Cfl - s1
Type - Pset_ManufacturerTypeInformation - Manufacturer: TARKETT
Type - Pset_QuantityTakeOff - Reference: TARKETT - Omnisports Active+ - Coral
Type - PSet_Tarkett_ES - Calefacción radiante: yes; Resistencia a la tracción: 0; Tipo de pavimento: Pavimento deportivo de interior en vinilo heterogéneo; Inflamabilidad: Cfl - s1; Resistencia térmica: 0.12 kg/K/s3; Design: Coral; Formato: 2m x 20.5lm; Plastificante: Libre de ftalatos; Reacción al fuego: Cfl - s1; Absorción acústica: Clase A (≤65dB); Punzonamiento estático: ≤ 0.50 mm; Peso total: 4.76; Espesor total: 8.1 mm; Emisiones COV tras 28 días: ≤ 10 μg/m³; URL: https://www.tarkettsportsindoor.com/; Abrasion: ≤ 0.25g; Absorción de impacto: P2 (≥35%); Alargamiento a la rotura: -; Brillo especular: ≤ 30; Coeficiente de fricción: 80 a 110; Deformación vertical: P2; Dimensiones de las tablas: -; Rango de temperatura: -; Rebote del Balón: ≥ 95%; Rendimiento acústico: 21 dB; Resistencia a cargas rodantes: ≤ 0.50 mm
Classification: C3020400 Flooring (Uniformat)
Pset_CoveringCommon - TotalThickness: 8.1 mm

# IfcCovering: Sol:TARKETT - Omnisports Active+ - Dark Beech, Sol:TARKETT - Omnisports Active+ - Dark Beech:373723
In: Niveau 1
Type - PredefinedType: FLOORING; Material: TARKETT - Omnisports Active+ - Dark Beech 8.1 mm
Type - Pset_ConcreteElementGeneral - FireRating: Cfl - s1
Type - Pset_CoveringCommon - Reference: TARKETT - Omnisports Active+ - Dark Beech; FireRating: Cfl - s1
Type - Pset_ManufacturerTypeInformation - Manufacturer: TARKETT
Type - Pset_QuantityTakeOff - Reference: TARKETT - Omnisports Active+ - Dark Beech
Type - PSet_Tarkett_ES - Calefacción radiante: yes; Resistencia a la tracción: 0; Tipo de pavimento: Pavimento deportivo de interior en vinilo heterogéneo; Inflamabilidad: Cfl - s1; Resistencia térmica: 0.12 kg/K/s3; Design: Dark Beech; Formato: 2m x 20.5lm; Plastificante: Libre de ftalatos; Reacción al fuego: Cfl - s1; Absorción acústica: Clase A (≤65dB); Punzonamiento estático: ≤ 0.50 mm; Peso total: 4.76; Espesor total: 8.1 mm; Emisiones COV tras 28 días: ≤ 10 μg/m³; URL: https://www.tarkettsportsindoor.com/; Abrasion: ≤ 0.25g; Absorción de impacto: P2 (≥35%); Alargamiento a la rotura: -; Brillo especular: ≤ 30; Coeficiente de fricción: 80 a 110; Deformación vertical: P2; Dimensiones de las tablas: -; Rango de temperatura: -; Rebote del Balón: ≥ 95%; Rendimiento acústico: 21 dB; Resistencia a cargas rodantes: ≤ 0.50 mm
Classification: C3020400 Flooring (Uniformat)
Pset_CoveringCommon - TotalThickness: 8.1 mm

# IfcCovering: Sol:TARKETT - Omnisports Active+ - Golden Maple, Sol:TARKETT - Omnisports Active+ - Golden Maple:373732
In: Niveau 1
Type - PredefinedType: FLOORING; Material: TARKETT - Omnisports Active+ - Maple GOLDEN MAPLE 8.1 mm
Type - Pset_ConcreteElementGeneral - FireRating: Cfl - s1
Type - Pset_CoveringCommon - Reference: TARKETT - Omnisports Active+ - Golden Maple; FireRating: Cfl - s1
Type - Pset_ManufacturerTypeInformation - Manufacturer: TARKETT
Type - Pset_QuantityTakeOff - Reference: TARKETT - Omnisports Active+ - Golden Maple
Type - PSet_Tarkett_ES - Calefacción radiante: yes; Resistencia a la tracción: 0; Tipo de pavimento: Pavimento deportivo de interior en vinilo heterogéneo; Inflamabilidad: Cfl - s1; Resistencia térmica: 0.12 kg/K/s3; Design: Golden Maple; Formato: 2m x 20.5lm; Plastificante: Libre de ftalatos; Reacción al fuego: Cfl - s1; Absorción acústica: Clase A (≤65dB); Punzonamiento estático: ≤ 0.50 mm; Peso total: 4.76; Espesor total: 8.1 mm; Emisiones COV tras 28 días: ≤ 10 μg/m³; URL: https://www.tarkettsportsindoor.com/; Abrasion: ≤ 0.25g; Absorción de impacto: P2 (≥35%); Alargamiento a la rotura: -; Brillo especular: ≤ 30; Coeficiente de fricción: 80 a 110; Deformación vertical: P2; Dimensiones de las tablas: -; Rango de temperatura: -; Rebote del Balón: ≥ 95%; Rendimiento acústico: 21 dB; Resistencia a cargas rodantes: ≤ 0.50 mm
Classification: C3020400 Flooring (Uniformat)
Pset_CoveringCommon - TotalThickness: 8.1 mm

# IfcCovering: Sol:TARKETT - Omnisports Active+ - Grey, Sol:TARKETT - Omnisports Active+ - Grey:373795
In: Niveau 1
Type - PredefinedType: FLOORING; Material: TARKETT - Omnisports Active+ - Uni GREY 8.1 mm
Type - Pset_ConcreteElementGeneral - FireRating: Cfl - s1
Type - Pset_CoveringCommon - Reference: TARKETT - Omnisports Active+ - Grey; FireRating: Cfl - s1
Type - Pset_ManufacturerTypeInformation - Manufacturer: TARKETT
Type - Pset_QuantityTakeOff - Reference: TARKETT - Omnisports Active+ - Grey
Type - PSet_Tarkett_ES - Calefacción radiante: yes; Resistencia a la tracción: 0; Tipo de pavimento: Pavimento deportivo de interior en vinilo heterogéneo; Inflamabilidad: Cfl - s1; Resistencia térmica: 0.12 kg/K/s3; Design: Grey; Formato: 2m x 20.5lm; Plastificante: Libre de ftalatos; Reacción al fuego: Cfl - s1; Absorción acústica: Clase A (≤65dB); Punzonamiento estático: ≤ 0.50 mm; Peso total: 4.76; Espesor total: 8.1 mm; Emisiones COV tras 28 días: ≤ 10 μg/m³; URL: https://www.tarkettsportsindoor.com/; Abrasion: ≤ 0.25g; Absorción de impacto: P2 (≥35%); Alargamiento a la rotura: -; Brillo especular: ≤ 30; Coeficiente de fricción: 80 a 110; Deformación vertical: P2; Dimensiones de las tablas: -; Rango de temperatura: -; Rebote del Balón: ≥ 95%; Rendimiento acústico: 21 dB; Resistencia a cargas rodantes: ≤ 0.50 mm
Classification: C3020400 Flooring (Uniformat)
Pset_CoveringCommon - TotalThickness: 8.1 mm

# IfcCovering: Sol:TARKETT - Omnisports Active+ - Lagoon, Sol:TARKETT - Omnisports Active+ - Lagoon:373804
In: Niveau 1
Type - PredefinedType: FLOORING; Material: TARKETT - Omnisports Active+ - Uni LAGOON 8.1 mm
Type - Pset_ConcreteElementGeneral - FireRating: Cfl - s1
Type - Pset_CoveringCommon - Reference: TARKETT - Omnisports Active+ - Lagoon; FireRating: Cfl - s1
Type - Pset_ManufacturerTypeInformation - Manufacturer: TARKETT
Type - Pset_QuantityTakeOff - Reference: TARKETT - Omnisports Active+ - Lagoon
Type - PSet_Tarkett_ES - Calefacción radiante: yes; Resistencia a la tracción: 0; Tipo de pavimento: Pavimento deportivo de interior en vinilo heterogéneo; Inflamabilidad: Cfl - s1; Resistencia térmica: 0.12 kg/K/s3; Design: Lagoon; Formato: 2m x 20.5lm; Plastificante: Libre de ftalatos; Reacción al fuego: Cfl - s1; Absorción acústica: Clase A (≤65dB); Punzonamiento estático: ≤ 0.50 mm; Peso total: 4.76; Espesor total: 8.1 mm; Emisiones COV tras 28 días: ≤ 10 μg/m³; URL: https://www.tarkettsportsindoor.com/; Abrasion: ≤ 0.25g; Absorción de impacto: P2 (≥35%); Alargamiento a la rotura: -; Brillo especular: ≤ 30; Coeficiente de fricción: 80 a 110; Deformación vertical: P2; Dimensiones de las tablas: -; Rango de temperatura: -; Rebote del Balón: ≥ 95%; Rendimiento acústico: 21 dB; Resistencia a cargas rodantes: ≤ 0.50 mm
Classification: C3020400 Flooring (Uniformat)
Pset_CoveringCommon - TotalThickness: 8.1 mm

# IfcCovering: Sol:TARKETT - Omnisports Active+ - Light Green, Sol:TARKETT - Omnisports Active+ - Light Green:373813
In: Niveau 1
Type - PredefinedType: FLOORING; Material: TARKETT - Omnisports Active+ - Uni LIGHT GREEN 8.1 mm
Type - Pset_ConcreteElementGeneral - FireRating: Cfl - s1
Type - Pset_CoveringCommon - Reference: TARKETT - Omnisports Active+ - Light Green; FireRating: Cfl - s1
Type - Pset_ManufacturerTypeInformation - Manufacturer: TARKETT
Type - Pset_QuantityTakeOff - Reference: TARKETT - Omnisports Active+ - Light Green
Type - PSet_Tarkett_ES - Calefacción radiante: yes; Resistencia a la tracción: 0; Tipo de pavimento: Pavimento deportivo de interior en vinilo heterogéneo; Inflamabilidad: Cfl - s1; Resistencia térmica: 0.12 kg/K/s3; Design: Light Green; Formato: 2m x 20.5lm; Plastificante: Libre de ftalatos; Reacción al fuego: Cfl - s1; Absorción acústica: Clase A (≤65dB); Punzonamiento estático: ≤ 0.50 mm; Peso total: 4.76; Espesor total: 8.1 mm; Emisiones COV tras 28 días: ≤ 10 μg/m³; URL: https://www.tarkettsportsindoor.com/; Abrasion: ≤ 0.25g; Absorción de impacto: P2 (≥35%); Alargamiento a la rotura: -; Brillo especular: ≤ 30; Coeficiente de fricción: 80 a 110; Deformación vertical: P2; Dimensiones de las tablas: -; Rango de temperatura: -; Rebote del Balón: ≥ 95%; Rendimiento acústico: 21 dB; Resistencia a cargas rodantes: ≤ 0.50 mm
Classification: C3020400 Flooring (Uniformat)
Pset_CoveringCommon - TotalThickness: 8.1 mm

# IfcCovering: Sol:TARKETT - Omnisports Active+ - Light Maple, Sol:TARKETT - Omnisports Active+ - Light Maple:373750
In: Niveau 1
Type - PredefinedType: FLOORING; Material: TARKETT - Omnisports Active+ - Maple LIGHT MAPLE 8.1 mm
Type - Pset_ConcreteElementGeneral - FireRating: Cfl - s1
Type - Pset_CoveringCommon - Reference: TARKETT - Omnisports Active+ - Light Maple; FireRating: Cfl - s1
Type - Pset_ManufacturerTypeInformation - Manufacturer: TARKETT
Type - Pset_QuantityTakeOff - Reference: TARKETT - Omnisports Active+ - Light Maple
Type - PSet_Tarkett_ES - Calefacción radiante: yes; Resistencia a la tracción: 0; Tipo de pavimento: Pavimento deportivo de interior en vinilo heterogéneo; Inflamabilidad: Cfl - s1; Resistencia térmica: 0.12 kg/K/s3; Design: Light Maple; Formato: 2m x 20.5lm; Plastificante: Libre de ftalatos; Reacción al fuego: Cfl - s1; Absorción acústica: Clase A (≤65dB); Punzonamiento estático: ≤ 0.50 mm; Peso total: 4.76; Espesor total: 8.1 mm; Emisiones COV tras 28 días: ≤ 10 μg/m³; URL: https://www.tarkettsportsindoor.com/; Abrasion: ≤ 0.25g; Absorción de impacto: P2 (≥35%); Alargamiento a la rotura: -; Brillo especular: ≤ 30; Coeficiente de fricción: 80 a 110; Deformación vertical: P2; Dimensiones de las tablas: -; Rango de temperatura: -; Rebote del Balón: ≥ 95%; Rendimiento acústico: 21 dB; Resistencia a cargas rodantes: ≤ 0.50 mm
Classification: C3020400 Flooring (Uniformat)
Pset_CoveringCommon - TotalThickness: 8.1 mm

# IfcCovering: Sol:TARKETT - Omnisports Active+ - Lime, Sol:TARKETT - Omnisports Active+ - Lime:373822
In: Niveau 1
Type - PredefinedType: FLOORING; Material: TARKETT - Omnisports Active+ - Uni LIME 8.1 mm
Type - Pset_ConcreteElementGeneral - FireRating: Cfl - s1
Type - Pset_CoveringCommon - Reference: TARKETT - Omnisports Active+ - Lime; FireRating: Cfl - s1
Type - Pset_ManufacturerTypeInformation - Manufacturer: TARKETT
Type - Pset_QuantityTakeOff - Reference: TARKETT - Omnisports Active+ - Lime
Type - PSet_Tarkett_ES - Calefacción radiante: yes; Resistencia a la tracción: 0; Tipo de pavimento: Pavimento deportivo de interior en vinilo heterogéneo; Inflamabilidad: Cfl - s1; Resistencia térmica: 0.12 kg/K/s3; Design: Lime; Formato: 2m x 20.5lm; Plastificante: Libre de ftalatos; Reacción al fuego: Cfl - s1; Absorción acústica: Clase A (≤65dB); Punzonamiento estático: ≤ 0.50 mm; Peso total: 4.76; Espesor total: 8.1 mm; Emisiones COV tras 28 días: ≤ 10 μg/m³; URL: https://www.tarkettsportsindoor.com/; Abrasion: ≤ 0.25g; Absorción de impacto: P2 (≥35%); Alargamiento a la rotura: -; Brillo especular: ≤ 30; Coeficiente de fricción: 80 a 110; Deformación vertical: P2; Dimensiones de las tablas: -; Rango de temperatura: -; Rebote del Balón: ≥ 95%; Rendimiento acústico: 21 dB; Resistencia a cargas rodantes: ≤ 0.50 mm
Classification: C3020400 Flooring (Uniformat)
Pset_CoveringCommon - TotalThickness: 8.1 mm

# IfcCovering: Sol:TARKETT - Omnisports Active+ - Magenta, Sol:TARKETT - Omnisports Active+ - Magenta:373831
In: Niveau 1
Type - PredefinedType: FLOORING; Material: TARKETT - Omnisports Active+ - Uni MAGENTA 8.1 mm
Type - Pset_ConcreteElementGeneral - FireRating: Cfl - s1
Type - Pset_CoveringCommon - Reference: TARKETT - Omnisports Active+ - Magenta; FireRating: Cfl - s1
Type - Pset_ManufacturerTypeInformation - Manufacturer: TARKETT
Type - Pset_QuantityTakeOff - Reference: TARKETT - Omnisports Active+ - Magenta
Type - PSet_Tarkett_ES - Calefacción radiante: yes; Resistencia a la tracción: 0; Tipo de pavimento: Pavimento deportivo de interior en vinilo heterogéneo; Inflamabilidad: Cfl - s1; Resistencia térmica: 0.12 kg/K/s3; Design: Magenta; Formato: 2m x 20.5lm; Plastificante: Libre de ftalatos; Reacción al fuego: Cfl - s1; Absorción acústica: Clase A (≤65dB); Punzonamiento estático: ≤ 0.50 mm; Peso total: 4.76; Espesor total: 8.1 mm; Emisiones COV tras 28 días: ≤ 10 μg/m³; URL: https://www.tarkettsportsindoor.com/; Abrasion: ≤ 0.25g; Absorción de impacto: P2 (≥35%); Alargamiento a la rotura: -; Brillo especular: ≤ 30; Coeficiente de fricción: 80 a 110; Deformación vertical: P2; Dimensiones de las tablas: -; Rango de temperatura: -; Rebote del Balón: ≥ 95%; Rendimiento acústico: 21 dB; Resistencia a cargas rodantes: ≤ 0.50 mm
Classification: C3020400 Flooring (Uniformat)
Pset_CoveringCommon - TotalThickness: 8.1 mm

# IfcCovering: Sol:TARKETT - Omnisports Active+ - Maple Grey, Sol:TARKETT - Omnisports Active+ - Maple Grey:373741
In: Niveau 1
Type - PredefinedType: FLOORING; Material: TARKETT - Omnisports Active+ - Maple GREY 8.1 mm
Type - Pset_ConcreteElementGeneral - FireRating: Cfl - s1
Type - Pset_CoveringCommon - Reference: TARKETT - Omnisports Active+ - Maple Grey; FireRating: Cfl - s1
Type - Pset_ManufacturerTypeInformation - Manufacturer: TARKETT
Type - Pset_QuantityTakeOff - Reference: TARKETT - Omnisports Active+ - Maple Grey
Type - PSet_Tarkett_ES - Calefacción radiante: yes; Resistencia a la tracción: 0; Tipo de pavimento: Pavimento deportivo de interior en vinilo heterogéneo; Inflamabilidad: Cfl - s1; Resistencia térmica: 0.12 kg/K/s3; Design: Maple Grey; Formato: 2m x 20.5lm; Plastificante: Libre de ftalatos; Reacción al fuego: Cfl - s1; Absorción acústica: Clase A (≤65dB); Punzonamiento estático: ≤ 0.50 mm; Peso total: 4.76; Espesor total: 8.1 mm; Emisiones COV tras 28 días: ≤ 10 μg/m³; URL: https://www.tarkettsportsindoor.com/; Abrasion: ≤ 0.25g; Absorción de impacto: P2 (≥35%); Alargamiento a la rotura: -; Brillo especular: ≤ 30; Coeficiente de fricción: 80 a 110; Deformación vertical: P2; Dimensiones de las tablas: -; Rango de temperatura: -; Rebote del Balón: ≥ 95%; Rendimiento acústico: 21 dB; Resistencia a cargas rodantes: ≤ 0.50 mm
Classification: C3020400 Flooring (Uniformat)
Pset_CoveringCommon - TotalThickness: 8.1 mm

# IfcCovering: Sol:TARKETT - Omnisports Active+ - Maple Red, Sol:TARKETT - Omnisports Active+ - Maple Red:373759
In: Niveau 1
Type - PredefinedType: FLOORING; Material: TARKETT - Omnisports Active+ - Maple RED 8.1 mm
Type - Pset_ConcreteElementGeneral - FireRating: Cfl - s1
Type - Pset_CoveringCommon - Reference: TARKETT - Omnisports Active+ - Maple Red; FireRating: Cfl - s1
Type - Pset_ManufacturerTypeInformation - Manufacturer: TARKETT
Type - Pset_QuantityTakeOff - Reference: TARKETT - Omnisports Active+ - Maple Red
Type - PSet_Tarkett_ES - Calefacción radiante: yes; Resistencia a la tracción: 0; Tipo de pavimento: Pavimento deportivo de interior en vinilo heterogéneo; Inflamabilidad: Cfl - s1; Resistencia térmica: 0.12 kg/K/s3; Design: Maple Red; Formato: 2m x 20.5lm; Plastificante: Libre de ftalatos; Reacción al fuego: Cfl - s1; Absorción acústica: Clase A (≤65dB); Punzonamiento estático: ≤ 0.50 mm; Peso total: 4.76; Espesor total: 8.1 mm; Emisiones COV tras 28 días: ≤ 10 μg/m³; URL: https://www.tarkettsportsindoor.com/; Abrasion: ≤ 0.25g; Absorción de impacto: P2 (≥35%); Alargamiento a la rotura: -; Brillo especular: ≤ 30; Coeficiente de fricción: 80 a 110; Deformación vertical: P2; Dimensiones de las tablas: -; Rango de temperatura: -; Rebote del Balón: ≥ 95%; Rendimiento acústico: 21 dB; Resistencia a cargas rodantes: ≤ 0.50 mm
Classification: C3020400 Flooring (Uniformat)
Pset_CoveringCommon - TotalThickness: 8.1 mm

# IfcCovering: Sol:TARKETT - Omnisports Active+ - Maple Sky Blue, Sol:TARKETT - Omnisports Active+ - Maple Sky Blue:373768
In: Niveau 1
Type - PredefinedType: FLOORING; Material: TARKETT - Omnisports Active+ - Maple SKY BLUE 8.1 mm
Type - Pset_ConcreteElementGeneral - FireRating: Cfl - s1
Type - Pset_CoveringCommon - Reference: TARKETT - Omnisports Active+ - Maple Sky Blue; FireRating: Cfl - s1
Type - Pset_ManufacturerTypeInformation - Manufacturer: TARKETT
Type - Pset_QuantityTakeOff - Reference: TARKETT - Omnisports Active+ - Maple Sky Blue
Type - PSet_Tarkett_ES - Calefacción radiante: yes; Resistencia a la tracción: 0; Tipo de pavimento: Pavimento deportivo de interior en vinilo heterogéneo; Inflamabilidad: Cfl - s1; Resistencia térmica: 0.12 kg/K/s3; Design: Maple Sky Blue; Formato: 2m x 20.5lm; Plastificante: Libre de ftalatos; Reacción al fuego: Cfl - s1; Absorción acústica: Clase A (≤65dB); Punzonamiento estático: ≤ 0.50 mm; Peso total: 4.76; Espesor total: 8.1 mm; Emisiones COV tras 28 días: ≤ 10 μg/m³; URL: https://www.tarkettsportsindoor.com/; Abrasion: ≤ 0.25g; Absorción de impacto: P2 (≥35%); Alargamiento a la rotura: -; Brillo especular: ≤ 30; Coeficiente de fricción: 80 a 110; Deformación vertical: P2; Dimensiones de las tablas: -; Rango de temperatura: -; Rebote del Balón: ≥ 95%; Rendimiento acústico: 21 dB; Resistencia a cargas rodantes: ≤ 0.50 mm
Classification: C3020400 Flooring (Uniformat)
Pset_CoveringCommon - TotalThickness: 8.1 mm

# IfcCovering: Sol:TARKETT - Omnisports Active+ - Mint Green, Sol:TARKETT - Omnisports Active+ - Mint Green:373840
In: Niveau 1
Type - PredefinedType: FLOORING; Material: TARKETT - Omnisports Active+ - Uni MINT GREEN 8.1 mm
Type - Pset_ConcreteElementGeneral - FireRating: Cfl - s1
Type - Pset_CoveringCommon - Reference: TARKETT - Omnisports Active+ - Mint Green; FireRating: Cfl - s1
Type - Pset_ManufacturerTypeInformation - Manufacturer: TARKETT
Type - Pset_QuantityTakeOff - Reference: TARKETT - Omnisports Active+ - Mint Green
Type - PSet_Tarkett_ES - Calefacción radiante: yes; Resistencia a la tracción: 0; Tipo de pavimento: Pavimento deportivo de interior en vinilo heterogéneo; Inflamabilidad: Cfl - s1; Resistencia térmica: 0.12 kg/K/s3; Design: Mint Green; Formato: 2m x 20.5lm; Plastificante: Libre de ftalatos; Reacción al fuego: Cfl - s1; Absorción acústica: Clase A (≤65dB); Punzonamiento estático: ≤ 0.50 mm; Peso total: 4.76; Espesor total: 8.1 mm; Emisiones COV tras 28 días: ≤ 10 μg/m³; URL: https://www.tarkettsportsindoor.com/; Abrasion: ≤ 0.25g; Absorción de impacto: P2 (≥35%); Alargamiento a la rotura: -; Brillo especular: ≤ 30; Coeficiente de fricción: 80 a 110; Deformación vertical: P2; Dimensiones de las tablas: -; Rango de temperatura: -; Rebote del Balón: ≥ 95%; Rendimiento acústico: 21 dB; Resistencia a cargas rodantes: ≤ 0.50 mm
Classification: C3020400 Flooring (Uniformat)
Pset_CoveringCommon - TotalThickness: 8.1 mm

# IfcCovering: Sol:TARKETT - Omnisports Active+ - Night Blue, Sol:TARKETT - Omnisports Active+ - Night Blue:373849
In: Niveau 1
Type - PredefinedType: FLOORING; Material: TARKETT - Omnisports Active+ - Uni NIGHT BLUE 8.1 mm
Type - Pset_ConcreteElementGeneral - FireRating: Cfl - s1
Type - Pset_CoveringCommon - Reference: TARKETT - Omnisports Active+ - Night Blue; FireRating: Cfl - s1
Type - Pset_ManufacturerTypeInformation - Manufacturer: TARKETT
Type - Pset_QuantityTakeOff - Reference: TARKETT - Omnisports Active+ - Night Blue
Type - PSet_Tarkett_ES - Calefacción radiante: yes; Resistencia a la tracción: 0; Tipo de pavimento: Pavimento deportivo de interior en vinilo heterogéneo; Inflamabilidad: Cfl - s1; Resistencia térmica: 0.12 kg/K/s3; Design: Night Blue; Formato: 2m x 20.5lm; Plastificante: Libre de ftalatos; Reacción al fuego: Cfl - s1; Absorción acústica: Clase A (≤65dB); Punzonamiento estático: ≤ 0.50 mm; Peso total: 4.76; Espesor total: 8.1 mm; Emisiones COV tras 28 días: ≤ 10 μg/m³; URL: https://www.tarkettsportsindoor.com/; Abrasion: ≤ 0.25g; Absorción de impacto: P2 (≥35%); Alargamiento a la rotura: -; Brillo especular: ≤ 30; Coeficiente de fricción: 80 a 110; Deformación vertical: P2; Dimensiones de las tablas: -; Rango de temperatura: -; Rebote del Balón: ≥ 95%; Rendimiento acústico: 21 dB; Resistencia a cargas rodantes: ≤ 0.50 mm
Classification: C3020400 Flooring (Uniformat)
Pset_CoveringCommon - TotalThickness: 8.1 mm

# IfcCovering: Sol:TARKETT - Omnisports Active+ - Orange, Sol:TARKETT - Omnisports Active+ - Orange:373858
In: Niveau 1
Type - PredefinedType: FLOORING; Material: TARKETT - Omnisports Active+ - Uni ORANGE 8.1 mm
Type - Pset_ConcreteElementGeneral - FireRating: Cfl - s1
Type - Pset_CoveringCommon - Reference: TARKETT - Omnisports Active+ - Orange; FireRating: Cfl - s1
Type - Pset_ManufacturerTypeInformation - Manufacturer: TARKETT
Type - Pset_QuantityTakeOff - Reference: TARKETT - Omnisports Active+ - Orange
Type - PSet_Tarkett_ES - Calefacción radiante: yes; Resistencia a la tracción: 0; Tipo de pavimento: Pavimento deportivo de interior en vinilo heterogéneo; Inflamabilidad: Cfl - s1; Resistencia térmica: 0.12 kg/K/s3; Design: Orange; Formato: 2m x 20.5lm; Plastificante: Libre de ftalatos; Reacción al fuego: Cfl - s1; Absorción acústica: Clase A (≤65dB); Punzonamiento estático: ≤ 0.50 mm; Peso total: 4.76; Espesor total: 8.1 mm; Emisiones COV tras 28 días: ≤ 10 μg/m³; URL: https://www.tarkettsportsindoor.com/; Abrasion: ≤ 0.25g; Absorción de impacto: P2 (≥35%); Alargamiento a la rotura: -; Brillo especular: ≤ 30; Coeficiente de fricción: 80 a 110; Deformación vertical: P2; Dimensiones de las tablas: -; Rango de temperatura: -; Rebote del Balón: ≥ 95%; Rendimiento acústico: 21 dB; Resistencia a cargas rodantes: ≤ 0.50 mm
Classification: C3020400 Flooring (Uniformat)
Pset_CoveringCommon - TotalThickness: 8.1 mm

# IfcCovering: Sol:TARKETT - Omnisports Active+ - Purple, Sol:TARKETT - Omnisports Active+ - Purple:373867
In: Niveau 1
Type - PredefinedType: FLOORING; Material: TARKETT - Omnisports Active+ - Uni PURPLE 8.1 mm
Type - Pset_ConcreteElementGeneral - FireRating: Cfl - s1
Type - Pset_CoveringCommon - Reference: TARKETT - Omnisports Active+ - Purple; FireRating: Cfl - s1
Type - Pset_ManufacturerTypeInformation - Manufacturer: TARKETT
Type - Pset_QuantityTakeOff - Reference: TARKETT - Omnisports Active+ - Purple
Type - PSet_Tarkett_ES - Calefacción radiante: yes; Resistencia a la tracción: 0; Tipo de pavimento: Pavimento deportivo de interior en vinilo heterogéneo; Inflamabilidad: Cfl - s1; Resistencia térmica: 0.12 kg/K/s3; Design: Purple; Formato: 2m x 20.5lm; Plastificante: Libre de ftalatos; Reacción al fuego: Cfl - s1; Absorción acústica: Clase A (≤65dB); Punzonamiento estático: ≤ 0.50 mm; Peso total: 4.76; Espesor total: 8.1 mm; Emisiones COV tras 28 días: ≤ 10 μg/m³; URL: https://www.tarkettsportsindoor.com/; Abrasion: ≤ 0.25g; Absorción de impacto: P2 (≥35%); Alargamiento a la rotura: -; Brillo especular: ≤ 30; Coeficiente de fricción: 80 a 110; Deformación vertical: P2; Dimensiones de las tablas: -; Rango de temperatura: -; Rebote del Balón: ≥ 95%; Rendimiento acústico: 21 dB; Resistencia a cargas rodantes: ≤ 0.50 mm
Classification: C3020400 Flooring (Uniformat)
Pset_CoveringCommon - TotalThickness: 8.1 mm

# IfcCovering: Sol:TARKETT - Omnisports Active+ - Red, Sol:TARKETT - Omnisports Active+ - Red:373876
In: Niveau 1
Type - PredefinedType: FLOORING; Material: TARKETT - Omnisports Active+ - Uni RED 8.1 mm
Type - Pset_ConcreteElementGeneral - FireRating: Cfl - s1
Type - Pset_CoveringCommon - Reference: TARKETT - Omnisports Active+ - Red; FireRating: Cfl - s1
Type - Pset_ManufacturerTypeInformation - Manufacturer: TARKETT
Type - Pset_QuantityTakeOff - Reference: TARKETT - Omnisports Active+ - Red
Type - PSet_Tarkett_ES - Calefacción radiante: yes; Resistencia a la tracción: 0; Tipo de pavimento: Pavimento deportivo de interior en vinilo heterogéneo; Inflamabilidad: Cfl - s1; Resistencia térmica: 0.12 kg/K/s3; Design: Red; Formato: 2m x 20.5lm; Plastificante: Libre de ftalatos; Reacción al fuego: Cfl - s1; Absorción acústica: Clase A (≤65dB); Punzonamiento estático: ≤ 0.50 mm; Peso total: 4.76; Espesor total: 8.1 mm; Emisiones COV tras 28 días: ≤ 10 μg/m³; URL: https://www.tarkettsportsindoor.com/; Abrasion: ≤ 0.25g; Absorción de impacto: P2 (≥35%); Alargamiento a la rotura: -; Brillo especular: ≤ 30; Coeficiente de fricción: 80 a 110; Deformación vertical: P2; Dimensiones de las tablas: -; Rango de temperatura: -; Rebote del Balón: ≥ 95%; Rendimiento acústico: 21 dB; Resistencia a cargas rodantes: ≤ 0.50 mm
Classification: C3020400 Flooring (Uniformat)
Pset_CoveringCommon - TotalThickness: 8.1 mm

# IfcCovering: Sol:TARKETT - Omnisports Active+ - Royal Blue, Sol:TARKETT - Omnisports Active+ - Royal Blue:373885
In: Niveau 1
Type - PredefinedType: FLOORING; Material: TARKETT - Omnisports Active+ - Uni ROYAL BLUE 8.1 mm
Type - Pset_ConcreteElementGeneral - FireRating: Cfl - s1
Type - Pset_CoveringCommon - Reference: TARKETT - Omnisports Active+ - Royal Blue; FireRating: Cfl - s1
Type - Pset_ManufacturerTypeInformation - Manufacturer: TARKETT
Type - Pset_QuantityTakeOff - Reference: TARKETT - Omnisports Active+ - Royal Blue
Type - PSet_Tarkett_ES - Calefacción radiante: yes; Resistencia a la tracción: 0; Tipo de pavimento: Pavimento deportivo de interior en vinilo heterogéneo; Inflamabilidad: Cfl - s1; Resistencia térmica: 0.12 kg/K/s3; Design: Royal Blue; Formato: 2m x 20.5lm; Plastificante: Libre de ftalatos; Reacción al fuego: Cfl - s1; Absorción acústica: Clase A (≤65dB); Punzonamiento estático: ≤ 0.50 mm; Peso total: 4.76; Espesor total: 8.1 mm; Emisiones COV tras 28 días: ≤ 10 μg/m³; URL: https://www.tarkettsportsindoor.com/; Abrasion: ≤ 0.25g; Absorción de impacto: P2 (≥35%); Alargamiento a la rotura: -; Brillo especular: ≤ 30; Coeficiente de fricción: 80 a 110; Deformación vertical: P2; Dimensiones de las tablas: -; Rango de temperatura: -; Rebote del Balón: ≥ 95%; Rendimiento acústico: 21 dB; Resistencia a cargas rodantes: ≤ 0.50 mm
Classification: C3020400 Flooring (Uniformat)
Pset_CoveringCommon - TotalThickness: 8.1 mm

# IfcCovering: Sol:TARKETT - Omnisports Active+ - Sky Blue, Sol:TARKETT - Omnisports Active+ - Sky Blue:373894
In: Niveau 1
Type - PredefinedType: FLOORING; Material: TARKETT - Omnisports Active+ - Uni SKY BLUE 8.1 mm
Type - Pset_ConcreteElementGeneral - FireRating: Cfl - s1
Type - Pset_CoveringCommon - Reference: TARKETT - Omnisports Active+ - Sky Blue; FireRating: Cfl - s1
Type - Pset_ManufacturerTypeInformation - Manufacturer: TARKETT
Type - Pset_QuantityTakeOff - Reference: TARKETT - Omnisports Active+ - Sky Blue
Type - PSet_Tarkett_ES - Calefacción radiante: yes; Resistencia a la tracción: 0; Tipo de pavimento: Pavimento deportivo de interior en vinilo heterogéneo; Inflamabilidad: Cfl - s1; Resistencia térmica: 0.12 kg/K/s3; Design: Sky Blue; Formato: 2m x 20.5lm; Plastificante: Libre de ftalatos; Reacción al fuego: Cfl - s1; Absorción acústica: Clase A (≤65dB); Punzonamiento estático: ≤ 0.50 mm; Peso total: 4.76; Espesor total: 8.1 mm; Emisiones COV tras 28 días: ≤ 10 μg/m³; URL: https://www.tarkettsportsindoor.com/; Abrasion: ≤ 0.25g; Absorción de impacto: P2 (≥35%); Alargamiento a la rotura: -; Brillo especular: ≤ 30; Coeficiente de fricción: 80 a 110; Deformación vertical: P2; Dimensiones de las tablas: -; Rango de temperatura: -; Rebote del Balón: ≥ 95%; Rendimiento acústico: 21 dB; Resistencia a cargas rodantes: ≤ 0.50 mm
Classification: C3020400 Flooring (Uniformat)
Pset_CoveringCommon - TotalThickness: 8.1 mm

# IfcCovering: Sol:TARKETT - Omnisports Active+ - Teal, Sol:TARKETT - Omnisports Active+ - Teal:373903
In: Niveau 1
Type - PredefinedType: FLOORING; Material: TARKETT - Omnisports Active+ - Uni TEAL 8.1 mm
Type - Pset_ConcreteElementGeneral - FireRating: Cfl - s1
Type - Pset_CoveringCommon - Reference: TARKETT - Omnisports Active+ - Teal; FireRating: Cfl - s1
Type - Pset_ManufacturerTypeInformation - Manufacturer: TARKETT
Type - Pset_QuantityTakeOff - Reference: TARKETT - Omnisports Active+ - Teal
Type - PSet_Tarkett_ES - Calefacción radiante: yes; Resistencia a la tracción: 0; Tipo de pavimento: Pavimento deportivo de interior en vinilo heterogéneo; Inflamabilidad: Cfl - s1; Resistencia térmica: 0.12 kg/K/s3; Design: Teal; Formato: 2m x 20.5lm; Plastificante: Libre de ftalatos; Reacción al fuego: Cfl - s1; Absorción acústica: Clase A (≤65dB); Punzonamiento estático: ≤ 0.50 mm; Peso total: 4.76; Espesor total: 8.1 mm; Emisiones COV tras 28 días: ≤ 10 μg/m³; URL: https://www.tarkettsportsindoor.com/; Abrasion: ≤ 0.25g; Absorción de impacto: P2 (≥35%); Alargamiento a la rotura: -; Brillo especular: ≤ 30; Coeficiente de fricción: 80 a 110; Deformación vertical: P2; Dimensiones de las tablas: -; Rango de temperatura: -; Rebote del Balón: ≥ 95%; Rendimiento acústico: 21 dB; Resistencia a cargas rodantes: ≤ 0.50 mm
Classification: C3020400 Flooring (Uniformat)
Pset_CoveringCommon - TotalThickness: 8.1 mm

# IfcCovering: Sol:TARKETT - Omnisports Active+ - Yellow, Sol:TARKETT - Omnisports Active+ - Yellow:373912
In: Niveau 1
Type - PredefinedType: FLOORING; Material: TARKETT - Omnisports Active+ - Uni YELLOW 8.1 mm
Type - Pset_ConcreteElementGeneral - FireRating: Cfl - s1
Type - Pset_CoveringCommon - Reference: TARKETT - Omnisports Active+ - Yellow; FireRating: Cfl - s1
Type - Pset_ManufacturerTypeInformation - Manufacturer: TARKETT
Type - Pset_QuantityTakeOff - Reference: TARKETT - Omnisports Active+ - Yellow
Type - PSet_Tarkett_ES - Calefacción radiante: yes; Resistencia a la tracción: 0; Tipo de pavimento: Pavimento deportivo de interior en vinilo heterogéneo; Inflamabilidad: Cfl - s1; Resistencia térmica: 0.12 kg/K/s3; Design: Yellow; Formato: 2m x 20.5lm; Plastificante: Libre de ftalatos; Reacción al fuego: Cfl - s1; Absorción acústica: Clase A (≤65dB); Punzonamiento estático: ≤ 0.50 mm; Peso total: 4.76; Espesor total: 8.1 mm; Emisiones COV tras 28 días: ≤ 10 μg/m³; URL: https://www.tarkettsportsindoor.com/; Abrasion: ≤ 0.25g; Absorción de impacto: P2 (≥35%); Alargamiento a la rotura: -; Brillo especular: ≤ 30; Coeficiente de fricción: 80 a 110; Deformación vertical: P2; Dimensiones de las tablas: -; Rango de temperatura: -; Rebote del Balón: ≥ 95%; Rendimiento acústico: 21 dB; Resistencia a cargas rodantes: ≤ 0.50 mm
Classification: C3020400 Flooring (Uniformat)
Pset_CoveringCommon - TotalThickness: 8.1 mm
